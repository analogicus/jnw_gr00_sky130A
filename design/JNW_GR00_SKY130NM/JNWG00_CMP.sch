v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {devices/ipin.sym} 80 -910 0 0 {name=p1 lab=VDD_1V8}
C {devices/ipin.sym} 80 -40 0 0 {name=p2 lab=VSS}
C {devices/ipin.sym} 80 -800 0 0 {name=p3 lab=PWRUP_1V8}
C {devices/ipin.sym} 90 -570 0 0 {name=p4 lab=CMP_IP}
C {devices/ipin.sym} 90 -480 0 0 {name=p5 lab=CMP_IN}
C {devices/opin.sym} 980 -480 2 1 {name=p6 lab=CMP_O}
C {devices/ipin.sym} 90 -270 0 0 {name=p7 lab=CK_CMP}
