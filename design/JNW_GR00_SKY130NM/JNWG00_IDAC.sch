v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
T {Coarse DAC} 1280 -1430 0 0 0.4 0.4 {}
T {Fine DAC} 1690 -1440 0 0 0.4 0.4 {}
N 2300 -1210 2300 -1140 {
lab=VS}
N 2300 -1110 2320 -1110 {
lab=VDD_1V8}
N 2320 -1240 2320 -1110 {
lab=VDD_1V8}
N 2300 -1240 2320 -1240 {
lab=VDD_1V8}
N 2320 -1270 2320 -1240 {
lab=VDD_1V8}
N 2300 -1270 2320 -1270 {
lab=VDD_1V8}
N 2300 -1330 2300 -1270 {
lab=VDD_1V8}
N 1930 -1240 2260 -1240 {
lab=VGP}
N 2300 -1080 2300 -900 {
lab=VD}
N 1310 -610 1330 -610 {
lab=VDD_1V8}
N 1310 -530 1330 -530 {
lab=VSS}
N 1250 -570 1270 -570 {
lab=PWRUP_1V8}
N 1190 -570 1250 -570 {
lab=PWRUP_1V8}
N 1350 -570 1410 -570 {
lab=PWR_N}
N 2000 -740 2030 -740 {
lab=VSS}
N 2030 -740 2160 -740 {
lab=VSS}
N 2390 -1270 2390 -730 {
lab=VDD_1V8}
N 2320 -1270 2390 -1270 {
lab=VDD_1V8}
N 2470 -1270 2470 -810 {
lab=VDD_1V8}
N 2390 -1270 2470 -1270 {
lab=VDD_1V8}
N 2470 -1270 2540 -1270 {
lab=VDD_1V8}
N 2600 -1270 2600 -1050 {
lab=VDD_1V8}
N 2540 -1270 2600 -1270 {
lab=VDD_1V8}
N 2300 -1050 2570 -1050 {
lab=VD}
N 2300 -900 2300 -730 {
lab=VD}
N 2300 -730 2360 -730 {
lab=VD}
N 2300 -810 2440 -810 {
lab=VD}
N 2300 -930 2510 -930 {
lab=VD}
N 2540 -1270 2540 -930 {
lab=VDD_1V8}
N 2630 -1050 2670 -1050 {
lab=IDAC_O[3]}
N 2570 -930 2610 -930 {
lab=IDAC_O[2]}
N 2500 -810 2540 -810 {
lab=IDAC_O[1]}
N 2420 -730 2460 -730 {
lab=IDAC_O[0]}
N 2390 -690 2460 -690 {
lab=IBO_N_1V8[0]}
N 2470 -770 2540 -770 {
lab=IBO_N_1V8[1]}
N 2540 -890 2610 -890 {
lab=IBO_N_1V8[2]}
N 2600 -1010 2670 -1010 {
lab=IBO_N_1V8[3]}
N 1200 -1080 1230 -1080 {
lab=IB[0]}
N 1200 -1100 1230 -1100 {
lab=IB[1]}
N 1200 -1120 1230 -1120 {
lab=IB[2]}
N 1200 -1140 1230 -1140 {
lab=IB[3]}
N 1200 -1160 1230 -1160 {
lab=IB[4]}
N 1200 -1220 1230 -1220 {
lab=IB[5]}
N 1200 -1240 1230 -1240 {
lab=IB[6]}
N 1230 -1220 1230 -1200 {
lab=IB[5]}
N 1200 -1280 1230 -1280 {
lab=IB[7]}
N 1230 -1260 1230 -1240 {
lab=IB[6]}
N 1450 -1280 1480 -1280 {
lab=VGP}
N 1200 -1040 1230 -1040 {
lab=VSS}
N 1230 -1300 1230 -1280 {
lab=IB[7]}
N 1230 -1180 1230 -1160 {
lab=IB[4]}
N 1760 -1290 1760 -1270 {
lab=#net1}
N 1760 -1210 1760 -1190 {
lab=#net2}
N 1760 -1130 1760 -1110 {
lab=#net3}
N 1760 -1050 1760 -1030 {
lab=#net4}
N 1760 -970 1760 -960 {
lab=#net5}
N 1760 -900 1760 -890 {
lab=#net6}
N 1760 -830 1760 -820 {
lab=#net7}
N 1760 -760 1760 -740 {
lab=#net8}
N 1760 -680 1760 -640 {
lab=VSS}
N 1760 -1370 1760 -1350 {
lab=VDD_1V8}
N 1870 -1360 1870 -1330 {
lab=VDD_1V8}
N 1760 -1360 1870 -1360 {
lab=VDD_1V8}
N 1870 -1270 1870 -1240 {
lab=#net8}
N 1620 -790 1650 -790 {
lab=VDD_1V8}
N 1620 -820 1760 -820 {
lab=#net7}
N 1630 -760 1760 -760 {
lab=#net8}
N 1620 -760 1630 -760 {
lab=#net8}
N 1620 -860 1650 -860 {
lab=VDD_1V8}
N 1620 -890 1760 -890 {
lab=#net6}
N 1630 -830 1760 -830 {
lab=#net7}
N 1620 -830 1630 -830 {
lab=#net7}
N 1620 -930 1650 -930 {
lab=VDD_1V8}
N 1620 -960 1760 -960 {
lab=#net5}
N 1630 -900 1760 -900 {
lab=#net6}
N 1620 -900 1630 -900 {
lab=#net6}
N 1620 -1000 1650 -1000 {
lab=VDD_1V8}
N 1620 -1030 1760 -1030 {
lab=#net4}
N 1630 -970 1760 -970 {
lab=#net5}
N 1620 -970 1630 -970 {
lab=#net5}
N 1620 -1080 1650 -1080 {
lab=VDD_1V8}
N 1620 -1110 1760 -1110 {
lab=#net3}
N 1630 -1050 1760 -1050 {
lab=#net4}
N 1620 -1050 1630 -1050 {
lab=#net4}
N 1620 -1160 1650 -1160 {
lab=VDD_1V8}
N 1620 -1190 1760 -1190 {
lab=#net2}
N 1630 -1130 1760 -1130 {
lab=#net3}
N 1620 -1130 1630 -1130 {
lab=#net3}
N 1620 -1240 1650 -1240 {
lab=VDD_1V8}
N 1620 -1270 1760 -1270 {
lab=#net1}
N 1630 -1210 1760 -1210 {
lab=#net2}
N 1620 -1210 1630 -1210 {
lab=#net2}
N 1620 -1320 1650 -1320 {
lab=VDD_1V8}
N 1620 -1350 1760 -1350 {
lab=VDD_1V8}
N 1630 -1290 1760 -1290 {
lab=#net1}
N 1620 -1290 1630 -1290 {
lab=#net1}
N 1500 -790 1580 -790 {
lab=IBF[7]}
N 1500 -860 1580 -860 {
lab=IBF[6]}
N 1500 -930 1580 -930 {
lab=IBF[5]}
N 1500 -1000 1580 -1000 {
lab=IBF[4]}
N 1500 -1080 1580 -1080 {
lab=IBF[3]}
N 1500 -1160 1580 -1160 {
lab=IBF[2]}
N 1490 -1240 1570 -1240 {
lab=IBF[1]}
N 1500 -1320 1580 -1320 {
lab=IBF[0]}
N 2660 -1040 2760 -1040 {
lab=IDAC_O[3]}
N 2660 -1050 2660 -1040 {
lab=IDAC_O[3]}
N 2300 -1340 2300 -1330 {
lab=VDD_1V8}
N 2010 -780 2010 -740 {
lab=VSS}
N 2010 -860 2010 -840 {
lab=#net9}
N 2010 -940 2010 -920 {
lab=#net10}
N 2010 -1020 2010 -1000 {
lab=#net11}
N 2010 -1100 2010 -1080 {
lab=#net12}
N 2010 -1180 2010 -1160 {
lab=#net13}
N 2010 -1210 2030 -1210 {
lab=VSS}
N 2030 -1210 2030 -740 {
lab=VSS}
N 2010 -810 2030 -810 {
lab=VSS}
N 2010 -890 2030 -890 {
lab=VSS}
N 2010 -970 2030 -970 {
lab=VSS}
N 2010 -1130 2030 -1130 {
lab=VSS}
N 1970 -1210 1970 -810 {
lab=PWR_N}
N 1920 -810 1970 -810 {
lab=PWR_N}
N 2010 -1050 2030 -1050 {
lab=VSS}
N 2220 -1110 2260 -1110 {
lab=#net14}
N 2180 -1170 2180 -1150 {
lab=VDD_1V8}
N 2180 -1170 2200 -1170 {
lab=VDD_1V8}
N 2180 -1070 2180 -1050 {
lab=VSS}
N 1870 -1240 1870 -750 {
lab=#net8}
N 1760 -750 1870 -750 {
lab=#net8}
C {devices/ipin.sym} 2300 -1340 0 0 {name=p1 lab=VDD_1V8}
C {devices/ipin.sym} 1190 -460 0 0 {name=p2 lab=VSS}
C {devices/ipin.sym} 1190 -570 0 0 {name=p3 lab=PWRUP_1V8}
C {JNW_ATR_SKY130NM/JNWATR_PCH_12C5F0.sym} 2260 -1240 0 0 {name=x1 }
C {JNW_ATR_SKY130NM/JNWATR_PCH_12C1F2.sym} 2260 -1110 0 0 {name=x2 }
C {SUN_TR_SKY130NM/SUNTR_IVX1_CV.sym} 1270 -570 0 0 {name=x13 }
C {devices/lab_wire.sym} 1330 -610 0 1 {name=p29 sig_type=std_logic lab=VDD_1V8}
C {devices/lab_wire.sym} 1330 -530 0 1 {name=p30 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2100 -740 0 1 {name=p31 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1410 -570 0 1 {name=p33 sig_type=std_logic lab=PWR_N}
C {devices/iopin.sym} 2590 -610 0 0 {name=p35 lab=IDAC_O[3:0]}
C {JNW_ATR_SKY130NM/JNWATR_PCH_8C1F2.sym} 2600 -1010 3 0 {name=x15 }
C {JNW_ATR_SKY130NM/JNWATR_PCH_8C1F2.sym} 2540 -890 3 0 {name=x16 }
C {JNW_ATR_SKY130NM/JNWATR_PCH_8C1F2.sym} 2470 -770 3 0 {name=x17 }
C {JNW_ATR_SKY130NM/JNWATR_PCH_8C1F2.sym} 2390 -690 3 0 {name=x18 }
C {devices/lab_wire.sym} 2460 -730 0 1 {name=p36 sig_type=std_logic lab=IDAC_O[0]}
C {devices/lab_wire.sym} 2540 -810 0 1 {name=p37 sig_type=std_logic lab=IDAC_O[1]}
C {devices/lab_wire.sym} 2610 -930 0 1 {name=p38 sig_type=std_logic lab=IDAC_O[2]}
C {devices/lab_wire.sym} 2670 -1050 0 1 {name=p39 sig_type=std_logic lab=IDAC_O[3]}
C {devices/lab_wire.sym} 2460 -690 0 1 {name=p40 sig_type=std_logic lab=IBO_N_1V8[0]}
C {devices/lab_wire.sym} 2540 -770 0 1 {name=p41 sig_type=std_logic lab=IBO_N_1V8[1]}
C {devices/lab_wire.sym} 2610 -890 0 1 {name=p42 sig_type=std_logic lab=IBO_N_1V8[2]}
C {devices/lab_wire.sym} 2670 -1010 0 1 {name=p43 sig_type=std_logic lab=IBO_N_1V8[3]}
C {devices/ipin.sym} 1200 -1360 0 0 {name=p44 lab=IB[7:0]}
C {devices/ipin.sym} 2350 -610 0 0 {name=p45 lab=IBO_N_1V8[3:0]}
C {devices/lab_wire.sym} 2300 -1170 0 1 {name=p47 sig_type=std_logic lab=VS}
C {devices/lab_wire.sym} 2350 -1050 0 1 {name=p48 sig_type=std_logic lab=VD}
C {devices/lab_wire.sym} 1950 -1240 0 1 {name=p49 sig_type=std_logic lab=VGP}
C {devices/lab_wire.sym} 1200 -1080 0 0 {name=p46 sig_type=std_logic lab=IB[0]
}
C {devices/lab_wire.sym} 1200 -1100 0 0 {name=p66 sig_type=std_logic lab=IB[1]
}
C {devices/lab_wire.sym} 1200 -1120 0 0 {name=p67 sig_type=std_logic lab=IB[2]
}
C {devices/lab_wire.sym} 1200 -1140 0 0 {name=p68 sig_type=std_logic lab=IB[3]
}
C {devices/lab_wire.sym} 1200 -1160 0 0 {name=p69 sig_type=std_logic lab=IB[4]
}
C {devices/lab_wire.sym} 1200 -1220 0 0 {name=p70 sig_type=std_logic lab=IB[5]
}
C {devices/lab_wire.sym} 1200 -1240 0 0 {name=p71 sig_type=std_logic lab=IB[6]
}
C {devices/lab_wire.sym} 1200 -1280 0 0 {name=p72 sig_type=std_logic lab=IB[7]
}
C {devices/lab_wire.sym} 1480 -1280 0 1 {name=p73 sig_type=std_logic lab=VGP
}
C {devices/lab_wire.sym} 1200 -1040 0 0 {name=p74 sig_type=std_logic lab=VSS
}
C {SUN_SAR9B_SKY130NM/SUNSAR_CDAC8_CV.sym} 1250 -1300 0 0 {name=x12}
C {devices/res.sym} 1760 -1320 0 0 {name=R1
value=1k
footprint=1206
device=resistor
m=1}
C {devices/res.sym} 1760 -1240 0 0 {name=R2
value=2k
footprint=1206
device=resistor
m=1}
C {devices/res.sym} 1760 -1160 0 0 {name=R3
value=4k
footprint=1206
device=resistor
m=1}
C {devices/res.sym} 1760 -1080 0 0 {name=R4
value=8k
footprint=1206
device=resistor
m=1}
C {devices/res.sym} 1760 -1000 0 0 {name=R5
value=16k
footprint=1206
device=resistor
m=1}
C {devices/res.sym} 1760 -930 0 0 {name=R6
value=32k
footprint=1206
device=resistor
m=1}
C {devices/res.sym} 1760 -860 0 0 {name=R7
value=64k
footprint=1206
device=resistor
m=1}
C {devices/res.sym} 1760 -790 0 0 {name=R8
value=128k
footprint=1206
device=resistor
m=1}
C {devices/res.sym} 1760 -710 0 0 {name=R9
value=256k
footprint=1206
device=resistor
m=1}
C {devices/lab_wire.sym} 1760 -640 0 0 {name=p32 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1760 -1370 0 1 {name=p75 sig_type=std_logic lab=VDD_1V8}
C {devices/capa.sym} 1870 -1300 0 0 {name=C2
m=1
value=100f
footprint=1206
device="ceramic capacitor"}
C {JNW_ATR_SKY130NM/JNWATR_PCH_8C1F2.sym} 1580 -790 0 0 {name=x19 }
C {devices/lab_wire.sym} 1650 -790 0 1 {name=p76 sig_type=std_logic lab=VDD_1V8}
C {JNW_ATR_SKY130NM/JNWATR_PCH_8C1F2.sym} 1580 -860 0 0 {name=x20 }
C {devices/lab_wire.sym} 1650 -860 0 1 {name=p77 sig_type=std_logic lab=VDD_1V8}
C {JNW_ATR_SKY130NM/JNWATR_PCH_8C1F2.sym} 1580 -930 0 0 {name=x21 }
C {devices/lab_wire.sym} 1650 -930 0 1 {name=p78 sig_type=std_logic lab=VDD_1V8}
C {JNW_ATR_SKY130NM/JNWATR_PCH_8C1F2.sym} 1580 -1000 0 0 {name=x22 }
C {devices/lab_wire.sym} 1650 -1000 0 1 {name=p79 sig_type=std_logic lab=VDD_1V8}
C {JNW_ATR_SKY130NM/JNWATR_PCH_8C1F2.sym} 1580 -1080 0 0 {name=x23 }
C {devices/lab_wire.sym} 1650 -1080 0 1 {name=p80 sig_type=std_logic lab=VDD_1V8}
C {JNW_ATR_SKY130NM/JNWATR_PCH_8C1F2.sym} 1580 -1160 0 0 {name=x24 }
C {devices/lab_wire.sym} 1650 -1160 0 1 {name=p81 sig_type=std_logic lab=VDD_1V8}
C {JNW_ATR_SKY130NM/JNWATR_PCH_8C1F2.sym} 1580 -1240 0 0 {name=x25 }
C {devices/lab_wire.sym} 1650 -1240 0 1 {name=p82 sig_type=std_logic lab=VDD_1V8}
C {JNW_ATR_SKY130NM/JNWATR_PCH_8C1F2.sym} 1580 -1320 0 0 {name=x26 }
C {devices/lab_wire.sym} 1650 -1320 0 1 {name=p83 sig_type=std_logic lab=VDD_1V8}
C {devices/lab_wire.sym} 1560 -790 2 1 {name=p116 sig_type=std_logic lab=IBF[7]
}
C {devices/lab_wire.sym} 1560 -860 2 1 {name=p117 sig_type=std_logic lab=IBF[6]
}
C {devices/lab_wire.sym} 1560 -930 2 1 {name=p118 sig_type=std_logic lab=IBF[5]
}
C {devices/lab_wire.sym} 1560 -1000 2 1 {name=p119 sig_type=std_logic lab=IBF[4]
}
C {devices/lab_wire.sym} 1560 -1080 2 1 {name=p120 sig_type=std_logic lab=IBF[3]
}
C {devices/lab_wire.sym} 1560 -1160 2 1 {name=p121 sig_type=std_logic lab=IBF[2]
}
C {devices/lab_wire.sym} 1550 -1240 2 1 {name=p122 sig_type=std_logic lab=IBF[1]
}
C {devices/lab_wire.sym} 1560 -1320 2 1 {name=p123 sig_type=std_logic lab=IBF[0]
}
C {devices/ipin.sym} 1550 -1360 0 0 {name=p124 lab=IBF[7:0]}
C {devices/lab_wire.sym} 1920 -810 0 0 {name=p34 sig_type=std_logic lab=PWR_N}
C {JNW_ATR_SKY130NM/JNWATR_NCH_2C5F0.sym} 1970 -1210 0 0 {name=x14 }
C {JNW_ATR_SKY130NM/JNWATR_NCH_2C5F0.sym} 1970 -1130 0 0 {name=x36 }
C {JNW_ATR_SKY130NM/JNWATR_NCH_2C5F0.sym} 1970 -1050 0 0 {name=x37 }
C {JNW_ATR_SKY130NM/JNWATR_NCH_2C5F0.sym} 1970 -970 0 0 {name=x38 }
C {JNW_ATR_SKY130NM/JNWATR_NCH_2C5F0.sym} 1970 -890 0 0 {name=x39 }
C {JNW_ATR_SKY130NM/JNWATR_NCH_2C5F0.sym} 1970 -810 0 0 {name=x40 }
C {devices/capa.sym} 1900 -1240 1 0 {name=C1
m=1
value=32f
footprint=1206
device="ceramic capacitor"}
C {SUN_TR_SKY130NM/SUNTR_TIEL_CV.sym} 2180 -1070 0 0 {name=x5 }
C {devices/lab_wire.sym} 2200 -1170 0 1 {name=p125 sig_type=std_logic lab=VDD_1V8}
C {devices/lab_wire.sym} 2180 -1050 0 1 {name=p126 sig_type=std_logic lab=VSS}
C {cborder/border_s.sym} 2310 -570 0 0 {
spice_ignore=true}
