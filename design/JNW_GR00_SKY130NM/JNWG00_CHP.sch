v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {devices/ipin.sym} 70 -900 0 0 {name=p1 lab=VDD_1V8}
C {devices/ipin.sym} 70 -30 0 0 {name=p2 lab=VSS}
C {devices/ipin.sym} 80 -560 0 0 {name=p4 lab=CHP_IP}
C {devices/ipin.sym} 80 -470 0 0 {name=p5 lab=CHP_IN}
C {devices/ipin.sym} 80 -260 0 0 {name=p7 lab=CHP_1V8}
C {devices/opin.sym} 400 -560 0 0 {name=p6 lab=CHP_IP}
C {devices/opin.sym} 400 -470 0 0 {name=p8 lab=CHP_IN}
