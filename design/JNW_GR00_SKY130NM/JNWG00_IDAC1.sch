v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
N 2300 -1210 2300 -1140 {
lab=VS}
N 2300 -1110 2320 -1110 {
lab=VDD_1V8}
N 2320 -1240 2320 -1110 {
lab=VDD_1V8}
N 2300 -1240 2320 -1240 {
lab=VDD_1V8}
N 2320 -1270 2320 -1240 {
lab=VDD_1V8}
N 2300 -1270 2320 -1270 {
lab=VDD_1V8}
N 2300 -1330 2300 -1270 {
lab=VDD_1V8}
N 1930 -1240 2260 -1240 {
lab=VGP}
N 1840 -1240 1930 -1240 {
lab=VGP}
N 2300 -1080 2300 -900 {
lab=VD}
N 290 -420 310 -420 {
lab=VDD_1V8}
N 290 -340 310 -340 {
lab=VSS}
N 230 -380 250 -380 {
lab=PWRUP_1V8}
N 170 -380 230 -380 {
lab=PWRUP_1V8}
N 330 -380 390 -380 {
lab=PWR_N}
N 2390 -1270 2390 -730 {
lab=VDD_1V8}
N 2320 -1270 2390 -1270 {
lab=VDD_1V8}
N 2470 -1270 2470 -810 {
lab=VDD_1V8}
N 2390 -1270 2470 -1270 {
lab=VDD_1V8}
N 2470 -1270 2540 -1270 {
lab=VDD_1V8}
N 2600 -1270 2600 -1050 {
lab=VDD_1V8}
N 2540 -1270 2600 -1270 {
lab=VDD_1V8}
N 2300 -1050 2570 -1050 {
lab=VD}
N 2300 -900 2300 -730 {
lab=VD}
N 2300 -730 2360 -730 {
lab=VD}
N 2300 -810 2440 -810 {
lab=VD}
N 2300 -930 2510 -930 {
lab=VD}
N 2540 -1270 2540 -930 {
lab=VDD_1V8}
N 2630 -1050 2670 -1050 {
lab=IDAC_O[3]}
N 2570 -930 2610 -930 {
lab=IDAC_O[2]}
N 2500 -810 2540 -810 {
lab=IDAC_O[1]}
N 2420 -730 2460 -730 {
lab=IDAC_O[0]}
N 2390 -690 2460 -690 {
lab=IBO_N_1V8[0]}
N 2470 -770 2540 -770 {
lab=IBO_N_1V8[1]}
N 2540 -890 2610 -890 {
lab=IBO_N_1V8[2]}
N 2600 -1010 2670 -1010 {
lab=IBO_N_1V8[3]}
N 2160 -1010 2200 -1010 {
lab=VSS}
N 2240 -1080 2240 -1040 {
lab=#net1}
N 2200 -1080 2240 -1080 {
lab=#net1}
N 2200 -1080 2200 -1070 {
lab=#net1}
N 2240 -1080 2260 -1110 {
lab=#net1}
N 2180 -1040 2200 -1040 {
lab=VSS}
N 2180 -1040 2180 -1010 {
lab=VSS}
N 1560 -760 1560 -740 {
lab=VGP}
N 1750 -1240 1780 -1240 {
lab=VGP}
N 1750 -1240 1750 -740 {
lab=VGP}
N 1560 -740 1750 -740 {
lab=VGP}
N 1420 -890 1450 -890 {
lab=VDD_1V8}
N 1420 -860 1430 -860 {
lab=#net2}
N 1420 -960 1450 -960 {
lab=VDD_1V8}
N 1420 -930 1430 -930 {
lab=#net3}
N 1420 -1030 1450 -1030 {
lab=VDD_1V8}
N 1420 -1000 1430 -1000 {
lab=#net4}
N 1420 -1100 1450 -1100 {
lab=VDD_1V8}
N 1420 -1070 1430 -1070 {
lab=#net5}
N 1420 -1180 1450 -1180 {
lab=VDD_1V8}
N 1420 -1150 1430 -1150 {
lab=#net6}
N 1420 -1260 1450 -1260 {
lab=VDD_1V8}
N 1420 -1230 1430 -1230 {
lab=#net7}
N 1420 -1340 1450 -1340 {
lab=VDD_1V8}
N 1420 -1310 1430 -1310 {
lab=#net8}
N 1420 -1420 1450 -1420 {
lab=VDD_1V8}
N 1420 -1390 1430 -1390 {
lab=#net9}
N 1360 -890 1380 -890 {
lab=IBF[0]}
N 1360 -960 1380 -960 {
lab=IBF[1]}
N 1360 -1030 1380 -1030 {
lab=IBF[2]}
N 1360 -1100 1380 -1100 {
lab=IBF[3]}
N 1360 -1180 1380 -1180 {
lab=IBF[4]}
N 1360 -1260 1380 -1260 {
lab=IBF[5]}
N 1360 -1340 1380 -1340 {
lab=IBF[6]}
N 1360 -1420 1380 -1420 {
lab=IBF[0]}
N 2660 -1040 2760 -1040 {
lab=IDAC_O[3]}
N 2660 -1050 2660 -1040 {
lab=IDAC_O[3]}
N 2300 -1340 2300 -1330 {
lab=VDD_1V8}
N 1780 -1240 1840 -1240 {
lab=VGP}
N 2060 -1260 2060 -1240 {
lab=VGP}
N 2060 -1340 2060 -1320 {
lab=VDD_1V8}
N 2060 -1340 2300 -1340 {
lab=VDD_1V8}
N 2330 -110 2330 -90 {
lab=VSS}
N 2330 -140 2360 -140 {
lab=VSS}
N 2360 -140 2360 -90 {
lab=VSS}
N 2330 -90 2360 -90 {
lab=VSS}
N 2330 -200 2330 -170 {
lab=VS7}
N 2330 -230 2360 -230 {
lab=VSS}
N 2360 -230 2360 -140 {
lab=VSS}
N 2250 -230 2290 -230 {
lab=IB[7]}
N 2250 -140 2290 -140 {
lab=VGN}
N 810 -90 2330 -90 {
lab=VSS}
N 2070 -110 2070 -90 {
lab=VSS}
N 2070 -140 2100 -140 {
lab=VSS}
N 2100 -140 2100 -90 {
lab=VSS}
N 2070 -90 2100 -90 {
lab=VSS}
N 2070 -200 2070 -170 {
lab=VS6}
N 2070 -230 2100 -230 {
lab=VSS}
N 2100 -230 2100 -140 {
lab=VSS}
N 1990 -230 2030 -230 {
lab=IB[6]}
N 1990 -140 2030 -140 {
lab=VGN}
N 1800 -110 1800 -90 {
lab=VSS}
N 1800 -140 1830 -140 {
lab=VSS}
N 1830 -140 1830 -90 {
lab=VSS}
N 1800 -90 1830 -90 {
lab=VSS}
N 1800 -200 1800 -170 {
lab=VS5}
N 1800 -230 1830 -230 {
lab=VSS}
N 1830 -230 1830 -140 {
lab=VSS}
N 1720 -230 1760 -230 {
lab=IB[5]}
N 1720 -140 1760 -140 {
lab=VGN}
N 1560 -110 1560 -90 {
lab=VSS}
N 1560 -140 1590 -140 {
lab=VSS}
N 1590 -140 1590 -90 {
lab=VSS}
N 1560 -90 1590 -90 {
lab=VSS}
N 1560 -200 1560 -170 {
lab=VS4}
N 1560 -230 1590 -230 {
lab=VSS}
N 1590 -230 1590 -140 {
lab=VSS}
N 1480 -230 1520 -230 {
lab=IB[4]}
N 1480 -140 1520 -140 {
lab=VGN}
N 1320 -110 1320 -90 {
lab=VSS}
N 1320 -140 1350 -140 {
lab=VSS}
N 1350 -140 1350 -90 {
lab=VSS}
N 1320 -90 1350 -90 {
lab=VSS}
N 1320 -200 1320 -170 {
lab=VS3}
N 1320 -230 1350 -230 {
lab=VSS}
N 1350 -230 1350 -140 {
lab=VSS}
N 1240 -230 1280 -230 {
lab=IB[3]}
N 1240 -140 1280 -140 {
lab=VGN}
N 1120 -110 1120 -90 {
lab=VSS}
N 1120 -140 1150 -140 {
lab=VSS}
N 1150 -140 1150 -90 {
lab=VSS}
N 1120 -90 1150 -90 {
lab=VSS}
N 1120 -200 1120 -170 {
lab=VS4}
N 1120 -230 1150 -230 {
lab=VSS}
N 1150 -230 1150 -140 {
lab=VSS}
N 1040 -230 1080 -230 {
lab=IB[2]}
N 1040 -140 1080 -140 {
lab=VGN}
N 850 -140 880 -140 {
lab=VSS}
N 850 -140 850 -90 {
lab=VSS}
N 880 -110 880 -90 {
lab=VSS}
N 920 -140 1040 -140 {
lab=VGN}
N 880 -240 880 -170 {
lab=VGN}
N 880 -240 930 -240 {
lab=VGN}
N 930 -240 930 -140 {
lab=VGN}
N 880 -320 880 -240 {
lab=VGN}
N 880 -600 880 -570 {
lab=#net10}
N 1120 -260 2330 -260 {
lab=VGP}
N 1670 -740 1670 -260 {
lab=VGP}
N 880 -630 920 -630 {
lab=VDD_1V8}
N 910 -660 920 -630 {
lab=VDD_1V8}
N 880 -660 910 -660 {
lab=VDD_1V8}
N 880 -700 880 -660 {
lab=VDD_1V8}
N 780 -630 840 -630 {
lab=PWR_N}
N 700 -100 700 -90 {
lab=VSS}
N 700 -90 810 -90 {
lab=VSS}
N 700 -130 740 -130 {
lab=VSS}
N 740 -130 740 -90 {
lab=VSS}
N 700 -240 700 -160 {
lab=VGN}
N 700 -240 880 -240 {
lab=VGN}
N 600 -130 660 -130 {
lab=PWR_N}
N 880 -570 880 -500 {
lab=#net10}
N 880 -470 910 -470 {
lab=VDD_1V8}
N 910 -630 910 -470 {
lab=VDD_1V8}
N 880 -440 880 -380 {
lab=#net11}
N 840 -470 840 -410 {
lab=#net11}
N 840 -410 880 -410 {
lab=#net11}
N 790 -380 790 -220 {
lab=#net11}
N 790 -380 880 -380 {
lab=#net11}
N 790 -160 790 -90 {
lab=VSS}
N 1560 -860 1560 -820 {
lab=#net12}
N 1420 -920 1430 -920 {
lab=VDD_1V8}
N 1430 -920 1450 -920 {
lab=VDD_1V8}
N 1420 -990 1450 -990 {
lab=VDD_1V8}
N 1420 -1060 1450 -1060 {
lab=VDD_1V8}
N 1420 -1130 1450 -1130 {
lab=VDD_1V8}
N 1420 -1210 1450 -1210 {
lab=VDD_1V8}
N 1420 -1290 1450 -1290 {
lab=VDD_1V8}
N 1420 -1370 1450 -1370 {
lab=VDD_1V8}
N 1420 -1450 1450 -1450 {
lab=VDD_1V8}
N 2180 -1340 2180 -1320 {
lab=VDD_1V8}
N 2180 -1260 2200 -1080 {
lab=#net1}
N 1450 -920 1450 -890 {
lab=VDD_1V8}
N 1430 -860 1460 -860 {
lab=#net2}
N 1520 -860 1560 -860 {
lab=#net12}
N 1430 -930 1460 -930 {
lab=#net3}
N 1450 -990 1450 -960 {
lab=VDD_1V8}
N 1520 -930 1560 -930 {
lab=#net12}
N 1560 -930 1560 -860 {
lab=#net12}
N 1430 -1000 1460 -1000 {
lab=#net4}
N 1520 -1000 1560 -1000 {
lab=#net12}
N 1560 -1000 1560 -930 {
lab=#net12}
N 1450 -1060 1450 -1030 {
lab=VDD_1V8}
N 1430 -1070 1460 -1070 {
lab=#net5}
N 1520 -1070 1560 -1070 {
lab=#net12}
N 1560 -1070 1560 -1000 {
lab=#net12}
N 1430 -1150 1460 -1150 {
lab=#net6}
N 1530 -1150 1560 -1150 {
lab=#net12}
N 1560 -1150 1560 -1070 {
lab=#net12}
N 1450 -1130 1450 -1100 {
lab=VDD_1V8}
N 1450 -1210 1450 -1180 {
lab=VDD_1V8}
N 1430 -1230 1460 -1230 {
lab=#net7}
N 1520 -1230 1560 -1230 {
lab=#net12}
N 1560 -1230 1560 -1150 {
lab=#net12}
N 1450 -1290 1450 -1260 {
lab=VDD_1V8}
N 1430 -1310 1460 -1310 {
lab=#net8}
N 1520 -1310 1560 -1310 {
lab=#net12}
N 1560 -1310 1560 -1230 {
lab=#net12}
N 1430 -1390 1460 -1390 {
lab=#net9}
N 1520 -1390 1560 -1390 {
lab=#net12}
N 1560 -1390 1560 -1310 {
lab=#net12}
N 1450 -1370 1450 -1340 {
lab=VDD_1V8}
N 1450 -1450 1450 -1420 {
lab=VDD_1V8}
C {devices/ipin.sym} 170 -1010 0 0 {name=p1 lab=VDD_1V8}
C {devices/ipin.sym} 170 -170 0 0 {name=p2 lab=VSS}
C {devices/ipin.sym} 170 -380 0 0 {name=p3 lab=PWRUP_1V8}
C {JNW_ATR_SKY130NM/JNWATR_PCH_8C5F0.sym} 2260 -1240 0 0 {name=x1 }
C {JNW_ATR_SKY130NM/JNWATR_PCH_8C1F2.sym} 2260 -1110 0 0 {name=x2 }
C {devices/lab_wire.sym} 2300 -1330 0 1 {name=p28 sig_type=std_logic lab=VDD_1V8}
C {SUN_TR_SKY130NM/SUNTR_IVX1_CV.sym} 250 -380 0 0 {name=x13 }
C {devices/lab_wire.sym} 310 -420 0 1 {name=p29 sig_type=std_logic lab=VDD_1V8}
C {devices/lab_wire.sym} 310 -340 0 1 {name=p30 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2160 -1010 0 0 {name=p31 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 390 -380 0 1 {name=p33 sig_type=std_logic lab=PWR_N}
C {devices/iopin.sym} 2800 -1000 0 0 {name=p35 lab=IDAC_O[3:0]}
C {JNW_ATR_SKY130NM/JNWATR_PCH_8C1F2.sym} 2600 -1010 3 0 {name=x15 }
C {JNW_ATR_SKY130NM/JNWATR_PCH_8C1F2.sym} 2540 -890 3 0 {name=x16 }
C {JNW_ATR_SKY130NM/JNWATR_PCH_8C1F2.sym} 2470 -770 3 0 {name=x17 }
C {JNW_ATR_SKY130NM/JNWATR_PCH_8C1F2.sym} 2390 -690 3 0 {name=x18 }
C {devices/lab_wire.sym} 2460 -730 0 1 {name=p36 sig_type=std_logic lab=IDAC_O[0]}
C {devices/lab_wire.sym} 2540 -810 0 1 {name=p37 sig_type=std_logic lab=IDAC_O[1]}
C {devices/lab_wire.sym} 2610 -930 0 1 {name=p38 sig_type=std_logic lab=IDAC_O[2]}
C {devices/lab_wire.sym} 2670 -1050 0 1 {name=p39 sig_type=std_logic lab=IDAC_O[3]}
C {devices/lab_wire.sym} 2460 -690 0 1 {name=p40 sig_type=std_logic lab=IBO_N_1V8[0]}
C {devices/lab_wire.sym} 2540 -770 0 1 {name=p41 sig_type=std_logic lab=IBO_N_1V8[1]}
C {devices/lab_wire.sym} 2610 -890 0 1 {name=p42 sig_type=std_logic lab=IBO_N_1V8[2]}
C {devices/lab_wire.sym} 2670 -1010 0 1 {name=p43 sig_type=std_logic lab=IBO_N_1V8[3]}
C {devices/ipin.sym} 160 -780 0 0 {name=p44 lab=IBF[7:0]}
C {devices/ipin.sym} 2470 -640 0 0 {name=p45 lab=IBO_N_1V8[3:0]}
C {devices/lab_wire.sym} 2300 -1170 0 1 {name=p47 sig_type=std_logic lab=VS}
C {devices/lab_wire.sym} 2350 -1050 0 1 {name=p48 sig_type=std_logic lab=VD}
C {devices/lab_wire.sym} 1900 -1240 0 1 {name=p49 sig_type=std_logic lab=VGP}
C {JNW_ATR_SKY130NM/JNWATR_NCH_8C1F2.sym} 2240 -1040 0 1 {name=x5 }
C {devices/res.sym} 1490 -1390 1 0 {name=R1
value=1k
footprint=1206
device=resistor
m=1}
C {devices/res.sym} 1490 -1310 1 0 {name=R2
value=2k
footprint=1206
device=resistor
m=1}
C {devices/res.sym} 1490 -1230 1 0 {name=R3
value=4k
footprint=1206
device=resistor
m=1}
C {devices/res.sym} 1490 -1150 1 0 {name=R4
value=8k
footprint=1206
device=resistor
m=1}
C {devices/res.sym} 1490 -1070 1 0 {name=R5
value=16k
footprint=1206
device=resistor
m=1}
C {devices/res.sym} 1490 -1000 1 0 {name=R6
value=32k
footprint=1206
device=resistor
m=1}
C {devices/res.sym} 1490 -930 3 0 {name=R7
value=64k
footprint=1206
device=resistor
m=1}
C {devices/res.sym} 1490 -860 3 0 {name=R8
value=128k
footprint=1206
device=resistor
m=1}
C {JNW_ATR_SKY130NM/JNWATR_PCH_8C1F2.sym} 1380 -890 0 0 {name=x19 }
C {devices/lab_wire.sym} 1450 -890 0 1 {name=p76 sig_type=std_logic lab=VDD_1V8}
C {JNW_ATR_SKY130NM/JNWATR_PCH_8C1F2.sym} 1380 -960 0 0 {name=x20 }
C {devices/lab_wire.sym} 1450 -960 0 1 {name=p77 sig_type=std_logic lab=VDD_1V8}
C {JNW_ATR_SKY130NM/JNWATR_PCH_8C1F2.sym} 1380 -1030 0 0 {name=x21 }
C {devices/lab_wire.sym} 1450 -1030 0 1 {name=p78 sig_type=std_logic lab=VDD_1V8}
C {JNW_ATR_SKY130NM/JNWATR_PCH_8C1F2.sym} 1380 -1100 0 0 {name=x22 }
C {devices/lab_wire.sym} 1450 -1100 0 1 {name=p79 sig_type=std_logic lab=VDD_1V8}
C {JNW_ATR_SKY130NM/JNWATR_PCH_8C1F2.sym} 1380 -1180 0 0 {name=x23 }
C {devices/lab_wire.sym} 1450 -1180 0 1 {name=p80 sig_type=std_logic lab=VDD_1V8}
C {JNW_ATR_SKY130NM/JNWATR_PCH_8C1F2.sym} 1380 -1260 0 0 {name=x24 }
C {devices/lab_wire.sym} 1450 -1260 0 1 {name=p81 sig_type=std_logic lab=VDD_1V8}
C {JNW_ATR_SKY130NM/JNWATR_PCH_8C1F2.sym} 1380 -1340 0 0 {name=x25 }
C {devices/lab_wire.sym} 1450 -1340 0 1 {name=p82 sig_type=std_logic lab=VDD_1V8}
C {JNW_ATR_SKY130NM/JNWATR_PCH_8C1F2.sym} 1380 -1420 0 0 {name=x26 }
C {devices/lab_wire.sym} 1450 -1420 0 1 {name=p83 sig_type=std_logic lab=VDD_1V8}
C {devices/lab_wire.sym} 1360 -890 2 1 {name=p86 sig_type=std_logic lab=IBF[0]}
C {devices/lab_wire.sym} 1360 -960 2 1 {name=p89 sig_type=std_logic lab=IBF[1]}
C {devices/lab_wire.sym} 1360 -1030 2 1 {name=p92 sig_type=std_logic lab=IBF[2]}
C {devices/lab_wire.sym} 1360 -1100 2 1 {name=p95 sig_type=std_logic lab=IBF[3]}
C {devices/lab_wire.sym} 1360 -1180 2 1 {name=p98 sig_type=std_logic lab=IBF[4]}
C {devices/lab_wire.sym} 1360 -1260 2 1 {name=p101 sig_type=std_logic lab=IBF[5]}
C {devices/lab_wire.sym} 1360 -1340 2 1 {name=p104 sig_type=std_logic lab=IBF[6]}
C {devices/lab_wire.sym} 1360 -1420 2 1 {name=p107 sig_type=std_logic lab=IBF[7]}
C {devices/capa.sym} 2060 -1290 0 0 {name=C1
m=1
value=100f
footprint=1206
device="ceramic capacitor"}
C {JNW_ATR_SKY130NM/JNWATR_NCH_12C5F0.sym} 2290 -140 0 0 {name=x4[3:0]}
C {JNW_ATR_SKY130NM/JNWATR_NCH_12C1F2.sym} 2290 -230 0 0 {name=x6[3:0]}
C {devices/lab_wire.sym} 2250 -230 0 0 {name=p32 sig_type=std_logic lab=IB[7]
}
C {devices/res.sym} 880 -350 0 0 {name=R9
value=512k
footprint=1206
device=resistor
m=1}
C {devices/lab_wire.sym} 2250 -140 0 0 {name=p34 sig_type=std_logic lab=VGN}
C {devices/lab_wire.sym} 2330 -90 0 0 {name=p46 sig_type=std_logic lab=VSS}
C {JNW_ATR_SKY130NM/JNWATR_NCH_12C5F0.sym} 2030 -140 0 0 {name=x11[1:0]}
C {JNW_ATR_SKY130NM/JNWATR_NCH_12C1F2.sym} 2030 -230 0 0 {name=x2[1:0]}
C {devices/lab_wire.sym} 1990 -230 0 0 {name=p66 sig_type=std_logic lab=IB[6]}
C {devices/lab_wire.sym} 1990 -140 0 0 {name=p67 sig_type=std_logic lab=VGN}
C {JNW_ATR_SKY130NM/JNWATR_NCH_12C5F0.sym} 1760 -140 0 0 {name=x10}
C {JNW_ATR_SKY130NM/JNWATR_NCH_12C1F2.sym} 1760 -230 0 0 {name=x11}
C {devices/lab_wire.sym} 1720 -230 0 0 {name=p69 sig_type=std_logic lab=IB[5]}
C {devices/lab_wire.sym} 1720 -140 0 0 {name=p70 sig_type=std_logic lab=VGN}
C {JNW_ATR_SKY130NM/JNWATR_NCH_8C5F0.sym} 1520 -140 0 0 {name=x9}
C {JNW_ATR_SKY130NM/JNWATR_NCH_8C1F2.sym} 1520 -230 0 0 {name=x7}
C {devices/lab_wire.sym} 1480 -230 0 0 {name=p72 sig_type=std_logic lab=IB[4]}
C {devices/lab_wire.sym} 1480 -140 0 0 {name=p74 sig_type=std_logic lab=VGN}
C {JNW_ATR_SKY130NM/JNWATR_NCH_4C5F0.sym} 1280 -140 0 0 {name=x7[}
C {JNW_ATR_SKY130NM/JNWATR_NCH_4C1F2.sym} 1280 -230 0 0 {name=x8}
C {devices/lab_wire.sym} 1240 -230 0 0 {name=p125 sig_type=std_logic lab=IB[3]
}
C {devices/lab_wire.sym} 1240 -140 0 0 {name=p126 sig_type=std_logic lab=VGN}
C {JNW_ATR_SKY130NM/JNWATR_NCH_2C5F0.sym} 1080 -140 0 0 {name=x14}
C {JNW_ATR_SKY130NM/JNWATR_NCH_2C1F2.sym} 1080 -230 0 0 {name=x12}
C {devices/lab_wire.sym} 1040 -230 0 0 {name=p127 sig_type=std_logic lab=IB[2]}
C {devices/lab_wire.sym} 1040 -140 0 0 {name=p128 sig_type=std_logic lab=VGN}
C {JNW_ATR_SKY130NM/JNWATR_NCH_12C5F0.sym} 920 -140 0 1 {name=x37}
C {devices/lab_wire.sym} 880 -700 0 1 {name=p129 sig_type=std_logic lab=VDD_1V8}
C {devices/lab_wire.sym} 2330 -180 0 0 {name=p68 sig_type=std_logic lab=VS7
}
C {devices/lab_wire.sym} 2070 -180 0 0 {name=p71 sig_type=std_logic lab=VS6
}
C {devices/lab_wire.sym} 1800 -180 0 0 {name=p73 sig_type=std_logic lab=VS5
}
C {devices/lab_wire.sym} 1560 -180 0 0 {name=p124 sig_type=std_logic lab=VS4
}
C {devices/lab_wire.sym} 1320 -180 0 0 {name=p130 sig_type=std_logic lab=VS3
}
C {devices/lab_wire.sym} 1120 -180 0 0 {name=p131 sig_type=std_logic lab=VS4
}
C {JNW_ATR_SKY130NM/JNWATR_PCH_8C1F2.sym} 840 -630 0 0 {name=x35 }
C {devices/lab_wire.sym} 780 -630 0 0 {name=p132 sig_type=std_logic lab=PWR_N}
C {JNW_ATR_SKY130NM/JNWATR_NCH_2C5F0.sym} 660 -130 0 0 {name=x36}
C {devices/lab_wire.sym} 600 -130 0 0 {name=p133 sig_type=std_logic lab=PWR_N}
C {devices/ipin.sym} 160 -670 0 0 {name=p4 lab=IB[7:0]}
C {JNW_ATR_SKY130NM/JNWATR_PCH_8C5F0.sym} 840 -470 0 0 {name=x3 }
C {devices/capa.sym} 790 -190 0 0 {name=C2
m=1
value=1p
footprint=1206
device="ceramic capacitor"}
C {devices/res.sym} 1560 -790 0 0 {name=R11
value=256k
footprint=1206
device=resistor
m=1}
C {devices/capa.sym} 2180 -1290 0 0 {name=C3
m=1
value=100f
footprint=1206
device="ceramic capacitor"}
